options:
  parameters:
    generate_options: qt_gui
    id: expt_3
    output_language: python
    title: equalizer
  states: {}

blocks:
- name: G1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G3
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G4
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G5
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: G1
    high_cutoff_freq: '500'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: G2
    high_cutoff_freq: '3000'
    low_cutoff_freq: '550'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: G3
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: G4
    high_cutoff_freq: '8900'
    low_cutoff_freq: '6100'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: G5
    high_cutoff_freq: '14800'
    low_cutoff_freq: '9200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/khariwal/Desktop/ee340/EE340_Communications_Lab/Lab_1/Bach.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_1, '0', blocks_add_xx_0, '2']
- [band_pass_filter_0_2, '0', blocks_add_xx_0, '3']
- [band_pass_filter_0_3, '0', blocks_add_xx_0, '4']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
