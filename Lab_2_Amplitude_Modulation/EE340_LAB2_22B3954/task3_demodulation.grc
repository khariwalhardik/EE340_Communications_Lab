options:
  parameters:
    author: DELL
    generate_options: qt_gui
    id: EE340_LAB2_task3_DEMOD
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: audio_sink_2
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: data.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: signal1_task3
    format: FORMAT_WAV
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: signal2_task3
    format: FORMAT_WAV
    samp_rate: samp_rate_audio
  states: {}
- name: frequency
  id: qtgui_tab_widget
  parameters:
    label0: signal 1 after demod
    label1: signal 2 after demod
    label2: signal 1 before LPF
    label3: signal 2 before LPF
    num_tabs: '4'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '120000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '120000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: frequency@0
    name: signal1 demodulation
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: frequency@2
    name: signal1  before LPF
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: frequency@3
    name: signal2  before LPF
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: frequency@1
    name: signal2 demodulation
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: time@1
    name: signal2 after demod
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: time@0
    name: signal1 after demod
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: time@3
    name: signal2 before LPF
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: time@2
    name: signal 1 before LPF
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: time
  id: qtgui_tab_widget
  parameters:
    label0: signal 1 after demod
    label1: signal 2 after demod
    label2: signal 1 before LPF
    label3: signal 2 before LPF
    num_tabs: '4'
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_1, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0_0_1, '1']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_xx_0_0_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', qtgui_time_sink_x_1_1, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0_0, '0', audio_sink_2, '0']
- [low_pass_filter_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
