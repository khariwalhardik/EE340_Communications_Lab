options:
  parameters:
    author: khariwal
    generate_options: qt_gui
    id: task1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    label: alpha
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: delay_value
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '4'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: skip_head
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '4'
    widget: counter
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*5
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*5
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '4'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_khari_task2.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Original_Text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    comment: |-
      # Converts floating-point values
       (0.0 to 255.0) to
       8-bit unsigned integers 
      (0 to 255)
      # Clamps values outside 
      this range and rounds to
       the nearest integer
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: |-
      # Packs 8 input
       bits into one
       byte (uchar) 
      using LSB-first 
      or MSB-first ordering
      # Combines bits 
      efficiently 
      for serialization
       or modulation
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      # Skips the specified
       number of initial 
      samples 
      from the input
       stream
       (used to remove
       startup transients)
    num_items: skip_head
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      # Detects signal transitions by 
      comparing input against lower
       and upper thresholds
      # Uses hysteresis to avoid 
      rapid toggling due to noise
    high: '0.0100'
    init: '0'
    low: '-0.0100'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Since you're using K=8K=8,
       this block is unpacking each 
      byte (8-bit integer) from the
       complex int8 file source into 
      individual bits. This effectively 
      converts your byte stream into
       a bitstream for further processing.
    k: '8'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: |-
      dc blocker is not used when 
      using matched filtering
       using rrc filter
    length: '32'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      With this configuration, the 
      unpacked bits are being
       mapped to symbols according
       to the table [−1,1][−1,1].
      Each 8-bit chunk is converted 
      to either −1−1 or 11, representing the
       binary values of 00 and 11 respectively. 
      This maps your bitstream into a bipolar 
      format suitable for transmission or modulation.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      # Reduces the sample rate by
       the symbol rate (sps) after 
      pulse shaping
      # Applies low-pass filtering
       to avoid aliasing during
       downsampling
    decim: sps
    taps: '[1]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      This block upsamples the signal by 
      inserting 7 zeros between each original s
      ample, increasing the sample rate by a factor of 8.
      With taps = 1, it doesn’t apply any
       additional filtering here, as it is
       primarily focused on increasing 
      the sample rate 
      for the Root Raised Cosine filter.
    interp: sps
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate*5
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: '80000'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: use this block to match the sampling rate
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    comment: |-
      # Root Raised Cosine (RRC) Filter:
      # - Used to reduce Inter-Symbol Interference (ISI) in digital communication.
      # - Band-limits the signal to control bandwidth and minimize channel interference.
      # - Roll-off factor (alpha): Determines the excess bandwidth beyond the Nyquist rate.
      # - Combined RRC filters at transmitter and receiver approximate a Raised Cosine filter.
      # - Typical application: Bandwidth-limited systems like QAM/PSK modulations to maintain signal quality.
    decim: '1'
    gain: '3'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    comment: |-
      this block is used for match 
      filtering to get correct ouptut

      # Root Raised Cosine (RRC) Filter for matched filtering and pulse shaping
      # The RRC filter shapes the signal to minimize inter-symbol interference (ISI)
      # No DC Blocker is used because:
      # 1. The RRC filter has a symmetric frequency response, focusing on the symbol band, not DC (0 Hz).
      # 2. Most modulation schemes (e.g., BPSK, QPSK) use zero-mean symbol mapping, reducing any DC offset.
      # 3. Low-frequency and DC components are attenuated by the band-pass nature of the RRC filter.
    gain: '3'
    interp: '1'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: symbol_rate
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_delay_1, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_abs_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_1, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_delay_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
